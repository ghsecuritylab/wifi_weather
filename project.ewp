# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VE ST STM32L475VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L475xx; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: rt-thread\components\net\sal_socket\include\socket\sys_socket; rt-thread\include; rt-thread\components\net\sal_socket\include\dfs_net\sys_select; packages\button-v1.0.1; rt-thread\components\net\lwip-2.0.2\src; rt-thread\components\finsh; packages\pahomqtt-v1.1.0\MQTTClient-RT; rt-thread\components\net\lwip-2.0.2\src\include; board\CubeMX_Config\Inc; libraries\HAL_Drivers\config; libraries\HAL_Drivers; rt-thread\components\net\sal_socket\include\dfs_net; rt-thread\components\net\lwip-2.0.2\src\include\ipv4; rt-thread\libcpu\arm\common; rt-thread\components\net\lwip-2.0.2\src\arch\include; .; rt-thread\components\drivers\include; board; libraries\HAL_Drivers\drv_flash; rt-thread\components\libc\compilers\dlib; rt-thread\components\net\netdev\include; rt-thread\components\drivers\sensors; board\ports; rt-thread\libcpu\arm\cortex-m4; libraries\STM32L4xx_HAL\CMSIS\Include; applications; rt-thread\components\net\at\at_socket; packages\at_device-v1.6.0; rt-thread\components\dfs\filesystems\devfs; rt-thread\components\net\lwip-2.0.2\src\include\netif; rt-thread\components\net\sal_socket\impl; libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc; rt-thread\components\net\at\include; rt-thread\components\drivers\spi\sfud\inc; rt-thread\components\dfs\include; rt-thread\components\dfs\filesystems\elmfat; libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include; rt-thread\components\libc\compilers\common; packages\ap3216c-latest; packages\pahomqtt-v1.1.0\MQTTPacket\src; packages\aht10-latest; rt-thread\components\net\sal_socket\include; rt-thread\components\drivers\wlan; rt-thread\components\drivers\spi; rt-thread\components\net\sal_socket\include\socket; packages\EasyFlash-v3.2.1\inc; packages\fal-v0.2.0\inc; libraries\rt_ota\inc; libraries\wifi; packages\stm32_sdio-v1.0.0; packages\TJpgDec; packages\cJSON-v1.0.2; packages\hzzk
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkAdditionalLibs: libraries\rt_ota\libs\librt_ota_noalgo_0.1.2_stm32l4_iar.a; libraries\wifi\libwifi_6181_0.2.4_armcm4_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCIncludePath2: rt-thread\components\net\sal_socket\include\socket\sys_socket; rt-thread\include; rt-thread\components\net\sal_socket\include\dfs_net\sys_select; packages\button-v1.0.1; rt-thread\components\net\lwip-2.0.2\src; rt-thread\components\finsh; packages\pahomqtt-v1.1.0\MQTTClient-RT; rt-thread\components\net\lwip-2.0.2\src\include; board\CubeMX_Config\Inc; libraries\HAL_Drivers\config; libraries\HAL_Drivers; rt-thread\components\net\sal_socket\include\dfs_net; rt-thread\components\net\lwip-2.0.2\src\include\ipv4; rt-thread\libcpu\arm\common; rt-thread\components\net\lwip-2.0.2\src\arch\include; .; rt-thread\components\drivers\include; board; libraries\HAL_Drivers\drv_flash; rt-thread\components\libc\compilers\dlib; rt-thread\components\net\netdev\include; rt-thread\components\drivers\sensors; board\ports; rt-thread\libcpu\arm\cortex-m4; libraries\STM32L4xx_HAL\CMSIS\Include; applications; rt-thread\components\net\at\at_socket; packages\at_device-v1.6.0; rt-thread\components\dfs\filesystems\devfs; rt-thread\components\net\lwip-2.0.2\src\include\netif; rt-thread\components\net\sal_socket\impl; libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc; rt-thread\components\net\at\include; rt-thread\components\drivers\spi\sfud\inc; rt-thread\components\dfs\include; rt-thread\components\dfs\filesystems\elmfat; libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include; rt-thread\components\libc\compilers\common; packages\ap3216c-latest; packages\pahomqtt-v1.1.0\MQTTPacket\src; packages\aht10-latest; rt-thread\components\net\sal_socket\include; rt-thread\components\drivers\wlan; rt-thread\components\drivers\spi; rt-thread\components\net\sal_socket\include\socket
  ICCARM.CCOptLevel: 3
  group aht10
    packages/aht10-latest/: aht10.c sensor_asair_aht10.c
  group ap3216c
    packages/ap3216c-latest/: ap3216c.c sensor_lsc_ap3216c.c
  group Applications
    applications/: main.c
  group AT
    rt-thread/components/net/at/src/: at_cli.c at_client.c at_utils.c
    rt-thread/components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-v1.6.0/: at_socket_esp8266.c
  group button_drive
    packages/button-v1.0.1/: button.c
  group Cjson
    packages/cJSON-v1.0.2/: cJSON.c cJSON.h cJSON_port.c cJSON_util.c cJSON_util.h utf8togbk.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/sdio/: block_dev.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c spi_flash_sfud.c spi_flash_w25qxx.c spi_msd.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group dlib
    rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group Drivers
    board/: board.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_qspi.c drv_rtc.c drv_soft_i2c.c drv_spi.c drv_spi_tfcard.c drv_usart.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_l4.c
    board/ports/: drv_qspi_flash.c sensor_port.c
    libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l475xx.s
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
  group EasyFlash
    packages/EasyFlash-v3.2.1/src/: easyflash.c ef_cmd.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
    board/ports/: ef_fal_port.c
  group fal
    packages/fal-v0.2.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    board/ports/: fal_flash_sfud_port.c fal_flash_stm32l4_port.c
  group Filesystem
    rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group finsh
    rt-thread/components/finsh/: cmd.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group HZ
    packages/hzzk/: fontupd.c fontupd.h text.c text.h
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    rt-thread/components/libc/compilers/common/: gmtime_r.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    rt-thread/components/net/sal_socket/impl/: af_inet_at.c af_inet_lwip.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/src/: sal_socket.c
  group Sensors
    rt-thread/components/drivers/sensors/: sensor.c
  group STM32_HAL
    libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c
    libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group TJpgDec
    packages/TJpgDec/: tjpgd.c tjpgd.h
    packages/TJpgDec/examples/: tjpgd_pic.c
  group User/task
    applications/: esp_task.c key_task.c lcd_task.c led_task.c sensor_task.c
